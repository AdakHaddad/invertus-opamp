** sch_path: inverter/sch/ringosc3_tb.sch
**.subckt ringosc3_tb
x1 net1 out GND ringosc3
V1 net1 GND 1.8
**.ends
.GLOBAL GND
.end
